Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-04-14T16:40:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Interface alternative d'export 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 14 16:40:29 2021 * Host: User-PC * Database: C:\Users\User\AppData\Local\Temp\{C0727D46-7FF3-4A9F-A890-64A3DB3B6ADA}\ifc * Database version: 5507 * Database creation date: Wed Apr 14 16:40:26 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 14 16:40:26 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 14 16:40:26 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no

# IfcFlowMovingDevice: EXTH ECOWATT PR 04 VM, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 04 VM:293559
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Grille_extraction: 0.1 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM; Visibilité_marque: yes
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; B': 0.533 m; C: 0.32 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.16 m; ØD1_Int: 0.156 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400007; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 04 VM Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 04 VM; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 21 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 0.7 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 70 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 480 m³/h; Debit_mini: 20 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 04 VM; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 04 VM; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 04 VM; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 04 VM
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 1.0164 m2; Volume: 0.065618 m3
Données d'identification - Identifiant: 44
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 04 VM ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 04 VM ISOLE:293597
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.1 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; B': 0.533 m; C: 0.347 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.16 m; ØD1_Int: 0.156 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400006; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 04 VM IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 04 VM ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 24 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 0.7 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 70 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 480 m³/h; Debit_mini: 20 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 04 VM ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 04 VM ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 04 VM ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 04 VM ISOLE
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 1.04324 m2; Volume: 0.0722742 m3
Données d'identification - Identifiant: 45
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 06 VM, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 06 VM:293611
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.14 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; B': 0.533 m; C: 0.32 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.2 m; ØD1_Int: 0.196 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400015; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 06 VM Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 06 VM; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 21 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 130 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 660 m³/h; Debit_mini: 70 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 06 VM; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 06 VM; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 06 VM; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 06 VM
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.02959 m2; Volume: 0.0656429 m3
Données d'identification - Identifiant: 46
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 06 VM ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 06 VM ISOLE:293625
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.14 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; B': 0.533 m; C: 0.347 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.2 m; ØD1_Int: 0.196 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400014; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 06 VM IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 06 VM ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 24 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 130 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 660 m³/h; Debit_mini: 70 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 06 VM ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 06 VM ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 06 VM ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 06 VM ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.05643 m2; Volume: 0.0722991 m3
Données d'identification - Identifiant: 47
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 10 VM, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 10 VM:293639
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.19 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.616 m; B: 0.566 m; B': 0.583 m; C: 0.421 m; E: 0.569 m; F: 0.544 m; G: 0.207 m; H: 0.185 m; Hauteur_porte: 0.355 m; I: 0.166 m; J: 0.198 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400027; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 10 VM Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 10 VM; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 26 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 10 VM; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 10 VM; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 10 VM; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 10 VM
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.19998 m2; Volume: 0.100427 m3
Données d'identification - Identifiant: 48
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 10 VM ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 10 VM ISOLE:293653
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.19 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.616 m; B: 0.566 m; B': 0.583 m; C: 0.448 m; E: 0.569 m; F: 0.544 m; G: 0.207 m; H: 0.185 m; Hauteur_porte: 0.355 m; I: 0.166 m; J: 0.198 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400026; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 10 VM IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 10 VM ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 30 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 10 VM ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 10 VM ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 10 VM ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 10 VM ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.22816 m2; Volume: 0.107784 m3
Données d'identification - Identifiant: 49
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 22 VM, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 22 VM:293667
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.295 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.756 m; B: 0.683 m; B': 0.701 m; C: 0.511 m; E: 0.709 m; F: 0.661 m; G: 0.252 m; H: 0.237 m; Hauteur_porte: 0.43 m; I: 0.236 m; J: 0.271 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400039; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 22 VM Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 22 VM; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 38 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 22 VM; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 22 VM; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 22 VM; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 22 VM
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.78341 m2; Volume: 0.194092 m3
Données d'identification - Identifiant: 50
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 22 VM ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 22 VM ISOLE:293681
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.295 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.756 m; B: 0.683 m; B': 0.701 m; C: 0.538 m; E: 0.709 m; F: 0.661 m; G: 0.252 m; H: 0.237 m; Hauteur_porte: 0.43 m; I: 0.236 m; J: 0.271 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400038; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 22 VM IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 22 VM ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 45 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 22 VM ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 22 VM ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 22 VM ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 22 VM ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.81853 m2; Volume: 0.20551 m3
Données d'identification - Identifiant: 51
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 30 VM, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 30 VM:293695
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; B': 0.874 m; C: 0.574 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410054; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 30 VM Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 30 VM; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 64 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 2.6 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.86747 m2; Volume: 0.355674 m3
Données d'identification - Identifiant: 52
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 30 VM ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 30 VM ISOLE:293709
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; B': 0.874 m; C: 0.6 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410052; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 30 VM IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 30 VM ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 73 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 2.6 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.91058 m2; Volume: 0.373469 m3
Données d'identification - Identifiant: 53
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 30 VM ISOLE Tri, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 30 VM ISOLE Tri:293723
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; B': 0.874 m; C: 0.6 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410053; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 30 VM IS Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 30 VM ISOLE Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 73 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.2 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM ISOLE Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM ISOLE Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM ISOLE Tri; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM ISOLE Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.91058 m2; Volume: 0.373469 m3
Données d'identification - Identifiant: 54
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 30 VM Tri, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 30 VM Tri:293737
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; B': 0.874 m; C: 0.574 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410055; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 30 VM Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 30 VM Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 64 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.2 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM Tri; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 30 VM Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.86747 m2; Volume: 0.355674 m3
Données d'identification - Identifiant: 55
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VM, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 38 VM:293751
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; B': 0.973 m; C: 0.639 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410078; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VM Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VM; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 78 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.62169 m2; Volume: 0.52018 m3
Données d'identification - Identifiant: 56
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VM ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 38 VM ISOLE:293765
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; B': 0.973 m; C: 0.666 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410076; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VM IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VM ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 88 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.67274 m2; Volume: 0.544183 m3
Données d'identification - Identifiant: 57
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VM ISOLE Tri, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 38 VM ISOLE Tri:293779
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; B': 0.973 m; C: 0.666 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410077; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VM IS Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VM ISOLE Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 88 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM ISOLE Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM ISOLE Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM ISOLE Tri; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM ISOLE Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.67274 m2; Volume: 0.544183 m3
Données d'identification - Identifiant: 58
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VM Tri, BIM_EXTH_ECOWATT_04à38_PR_VM:EXTH ECOWATT PR 38 VM Tri:293793
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VM
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; B': 0.973 m; C: 0.639 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410079; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VM Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VM Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 78 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM Tri; Type: BIM_EXTH_ECOWATT_04à38_PR_VM: EXTH ECOWATT PR 38 VM Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.62169 m2; Volume: 0.52018 m3
Données d'identification - Identifiant: 59
Génie climatique - Classification du système: Reprise,Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
