Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2021-04-14T17:15:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Interface alternative d'export 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 14 17:15:27 2021 * Host: User-PC * Database: C:\Users\User\AppData\Local\Temp\{5D3AEC26-2987-4A09-BFE8-B6B640D7B709}\ifc * Database version: 5507 * Database creation date: Wed Apr 14 17:15:25 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 14 17:15:26 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 14 17:15:26 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no

# IfcFlowMovingDevice: EXTH ECOWATT PR 10 VD, BIM_EXTH_ECOWATT_04à38_PR_VD:EXTH ECOWATT PR 10 VD:300382
In: Niveau 0
Type - Material: Acier, galvanisé, Rouge, Gris, Jaune
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Grille_extraction: 0.18 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VD; Visibilité_marque: yes
Type - Cotes(Type) - A: 0.804 m; B: 0.603 m; C: 0.421 m; E: 0.777 m; F: 0.544 m; G: 0.194 m; H: 0.161 m; Hauteur_porte: 0.355 m; I: 0.166 m; J: 0.198 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; ØD2: 0.2 m; ØD2_int: 0.196 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400023; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 10 VD Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 10 VD; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 32 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 0.15 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 10 VD; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 10 VD; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 10 VD; Type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 10 VD
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 1.52698 m2; Volume: 0.146188 m3
Données d'identification - Identifiant: 46
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 10 VD ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VD:EXTH ECOWATT PR 10 VD ISOLE:300420
In: Niveau 0
Type - Material: Acier, galvanisé, Rouge, Gris, Jaune
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.18 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VD
Type - Cotes(Type) - A: 0.804 m; B: 0.603 m; C: 0.448 m; E: 0.777 m; F: 0.544 m; G: 0.194 m; H: 0.161 m; Hauteur_porte: 0.355 m; I: 0.166 m; J: 0.198 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; ØD2: 0.2 m; ØD2_int: 0.196 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400022; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 10 VD IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 10 VD ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 32 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 0.15 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 10 VD ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 10 VD ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 10 VD ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 10 VD ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.56138 m2; Volume: 0.156884 m3
Données d'identification - Identifiant: 47
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 22 VD, BIM_EXTH_ECOWATT_04à38_PR_VD:EXTH ECOWATT PR 22 VD:300434
In: Niveau 0
Type - Material: Acier, galvanisé, Rouge, Gris, Jaune
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.285 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VD
Type - Cotes(Type) - A: 1.037 m; B: 0.72 m; C: 0.511 m; E: 0.998 m; F: 0.661 m; G: 0.239 m; H: 0.219 m; Hauteur_porte: 0.43 m; I: 0.236 m; J: 0.271 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; ØD2: 0.315 m; ØD2_int: 0.311 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400035; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 22 VD Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 22 VD; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 45 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 0.35 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 22 VD; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 22 VD; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 22 VD; Type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 22 VD
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.35378 m2; Volume: 0.291655 m3
Données d'identification - Identifiant: 48
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 22 VD ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VD:EXTH ECOWATT PR 22 VD ISOLE:300448
In: Niveau 0
Type - Material: Acier, galvanisé, Rouge, Gris, Jaune
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.285 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VD
Type - Cotes(Type) - A: 1.037 m; B: 0.72 m; C: 0.538 m; E: 0.998 m; F: 0.661 m; G: 0.239 m; H: 0.219 m; Hauteur_porte: 0.43 m; I: 0.236 m; J: 0.271 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; ØD2: 0.315 m; ØD2_int: 0.311 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400034; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 22 VD IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 22 VD ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 55 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 0.35 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 22 VD ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 22 VD ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 22 VD ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 22 VD ISOLE
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 2.39762 m2; Volume: 0.3088 m3
Données d'identification - Identifiant: 49
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VD, BIM_EXTH_ECOWATT_04à38_PR_VD:EXTH ECOWATT PR 38 VD:300462
In: Niveau 0
Type - Material: Acier, galvanisé, Rouge, Gris, Jaune
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.43 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VD
Type - Cotes(Type) - A: 1.422 m; B: 1.023 m; C: 0.639 m; E: 1.382 m; F: 0.894 m; G: 0.315 m; H: 0.273 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; ØD2: 0.4 m; ØD2_int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410070; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VD Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VD; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 83 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 0.7 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD; Type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 4.62174 m2; Volume: 0.76027 m3
Données d'identification - Identifiant: 50
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VD ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VD:EXTH ECOWATT PR 38 VD ISOLE:300476
In: Niveau 0
Type - Material: Acier, galvanisé, Rouge, Gris, Jaune
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.43 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VD
Type - Cotes(Type) - A: 1.422 m; B: 1.023 m; C: 0.666 m; E: 1.382 m; F: 0.894 m; G: 0.315 m; H: 0.273 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; ØD2: 0.4 m; ØD2_int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410068; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VD IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VD ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 94 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 0.7 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 4.68416 m2; Volume: 0.795303 m3
Données d'identification - Identifiant: 51
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VD ISOLE Tri, BIM_EXTH_ECOWATT_04à38_PR_VD:EXTH ECOWATT PR 38 VD ISOLE Tri:300490
In: Niveau 0
Type - Material: Acier, galvanisé, Rouge, Gris, Jaune
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.43 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VD
Type - Cotes(Type) - A: 1.422 m; B: 1.023 m; C: 0.666 m; E: 1.382 m; F: 0.894 m; G: 0.315 m; H: 0.273 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; ØD2: 0.4 m; ØD2_int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410069; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VD IS Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VD ISOLE Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 94 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 0.7 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD ISOLE Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD ISOLE Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD ISOLE Tri; Type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD ISOLE Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 4.68416 m2; Volume: 0.795303 m3
Données d'identification - Identifiant: 52
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VD Tri, BIM_EXTH_ECOWATT_04à38_PR_VD:EXTH ECOWATT PR 38 VD Tri:300504
In: Niveau 0
Type - Material: Acier, galvanisé, Rouge, Gris, Jaune
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.43 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VD
Type - Cotes(Type) - A: 1.422 m; B: 1.023 m; C: 0.639 m; E: 1.382 m; F: 0.894 m; G: 0.315 m; H: 0.273 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; ØD2: 0.4 m; ØD2_int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410071; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VD Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VD Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 83 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 0.7 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD Tri; Type: BIM_EXTH_ECOWATT_04à38_PR_VD: EXTH ECOWATT PR 38 VD Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 4.62174 m2; Volume: 0.76027 m3
Données d'identification - Identifiant: 53
Génie climatique - Classification du système: Puissance,Reprise,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
