Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-04-14T16:35:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Interface alternative d'export 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 14 16:35:09 2021 * Host: User-PC * Database: C:\Users\User\AppData\Local\Temp\{D7406745-7019-4C63-8AA7-B13133690842}\ifc * Database version: 5507 * Database creation date: Wed Apr 14 16:35:07 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 14 16:35:07 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 14 16:35:07 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no

# IfcFlowMovingDevice: EXTH ECOWATT PR 04 VL, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 04 VL:293612
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Grille_extraction: 0.1 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL; Visibilité_marque: yes
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; C: 0.32 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.16 m; ØD1_Int: 0.156 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400005; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 04 VL Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 04 VL; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 21 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 0.7 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 70 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 480 m³/h; Debit_mini: 20 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 04 VL; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 04 VL; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 04 VL; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 04 VL
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 0.99853 m2; Volume: 0.0655842 m3
Données d'identification - Identifiant: 46
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 04 VL ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 04 VL ISOLE:293642
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.1 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; C: 0.347 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.16 m; ØD1_Int: 0.156 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400004; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 04 VL IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 04 VL ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 24 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 0.7 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 70 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 480 m³/h; Debit_mini: 20 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 04 VL ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 04 VL ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 04 VL ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 04 VL ISOLE
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0
Cotes - Surface: 1.02537 m2; Volume: 0.0722404 m3
Données d'identification - Identifiant: 47
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 06 VL, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 06 VL:293654
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.14 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; C: 0.32 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.2 m; ØD1_Int: 0.196 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400013; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 06 VL Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 06 VL; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 21 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 130 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 660 m³/h; Debit_mini: 70 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 06 VL; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 06 VL; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 06 VL; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 06 VL
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.0072 m2; Volume: 0.0656006 m3
Données d'identification - Identifiant: 48
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 06 VL ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 06 VL ISOLE:293666
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.14 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.609 m; B: 0.523 m; C: 0.347 m; E: 0.568 m; F: 0.502 m; G: 0.157 m; H: 0.175 m; Hauteur_porte: 0.255 m; I: 0.13 m; J: 0.165 m; Largeur_porte: 0.439 m; ØD1: 0.2 m; ØD1_Int: 0.196 m; Pos_H_inter: 0.413 m; Pos_V_inter: 0.097 m
Type - Données d'identification(Type) - Code_article: 5400012; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 06 VL IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 06 VL ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 24 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 130 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 660 m³/h; Debit_mini: 70 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 06 VL ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 06 VL ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 06 VL ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 06 VL ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.03404 m2; Volume: 0.0722568 m3
Données d'identification - Identifiant: 49
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 10 VL, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 10 VL:293678
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.19 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.616 m; B: 0.566 m; C: 0.421 m; E: 0.569 m; F: 0.544 m; G: 0.207 m; H: 0.185 m; Hauteur_porte: 0.355 m; I: 0.166 m; J: 0.198 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400025; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 10 VL Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 10 VL; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 26 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 10 VL; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 10 VL; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 10 VL; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 10 VL
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.16647 m2; Volume: 0.100363 m3
Données d'identification - Identifiant: 50
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 10 VL ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 10 VL ISOLE:293690
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.19 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.616 m; B: 0.566 m; C: 0.448 m; E: 0.569 m; F: 0.544 m; G: 0.207 m; H: 0.185 m; Hauteur_porte: 0.355 m; I: 0.166 m; J: 0.198 m; Largeur_porte: 0.245 m; ØD1: 0.25 m; ØD1_Int: 0.246 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.095 m
Type - Données d'identification(Type) - Code_article: 5400024; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 10 VL IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 10 VL ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 30 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.2 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 150 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 1150 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 10 VL ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 10 VL ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 10 VL ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 10 VL ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.19466 m2; Volume: 0.10772 m3
Données d'identification - Identifiant: 51
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 22 VL, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 22 VL:293704
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.295 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.756 m; B: 0.683 m; C: 0.511 m; E: 0.709 m; F: 0.661 m; G: 0.252 m; H: 0.237 m; Hauteur_porte: 0.43 m; I: 0.236 m; J: 0.271 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400037; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 22 VL Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 22 VL; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 38 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 22 VL; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 22 VL; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 22 VL; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 22 VL
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.73461 m2; Volume: 0.193998 m3
Données d'identification - Identifiant: 52
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 22 VL ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 22 VL ISOLE:293716
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.295 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.756 m; B: 0.683 m; C: 0.538 m; E: 0.709 m; F: 0.661 m; G: 0.252 m; H: 0.237 m; Hauteur_porte: 0.43 m; I: 0.236 m; J: 0.271 m; Largeur_porte: 0.245 m; ØD1: 0.355 m; ØD1_Int: 0.351 m; Pos_H_inter: 0.192 m; Pos_V_inter: 0.115 m
Type - Données d'identification(Type) - Code_article: 5400036; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 22 VL IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 22 VL ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 45 kg
Type - Electricité(Type) - Classe_de_protection_electrique: B; Courant_nominal: 1.6 A; Nombre_de_phases: 1; Protection_IP: IP44; Puissance_electrique: 350 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 2200 m³/h; Debit_mini: 100 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 22 VL ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 22 VL ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 22 VL ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 22 VL ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 1.76974 m2; Volume: 0.205417 m3
Données d'identification - Identifiant: 53
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 30 VL, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 30 VL:293728
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; C: 0.574 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410050; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 30 VL Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 30 VL; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 64 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 2.6 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.77245 m2; Volume: 0.355489 m3
Données d'identification - Identifiant: 54
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 30 VL ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 30 VL ISOLE:293740
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; C: 0.6 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410048; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 30 VL IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 30 VL ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 73 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 2.6 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.81555 m2; Volume: 0.373284 m3
Données d'identification - Identifiant: 55
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 30 VL ISOLE Tri, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 30 VL ISOLE Tri:293752
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; C: 0.6 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410049; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 30 VL IS Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 30 VL ISOLE Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 73 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.2 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL ISOLE Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL ISOLE Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL ISOLE Tri; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL ISOLE Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.81555 m2; Volume: 0.373284 m3
Données d'identification - Identifiant: 56
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 30 VL Tri, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 30 VL Tri:293764
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.34 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 0.972 m; B: 0.824 m; C: 0.574 m; E: 0.89 m; F: 0.796 m; G: 0.28 m; H: 0.273 m; Hauteur_porte: 0.497 m; I: 0.243 m; J: 0.314 m; Largeur_porte: 0.648 m; ØD1: 0.4 m; ØD1_Int: 0.396 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410051; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 30 VL Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 30 VL Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 64 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.2 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 600 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 3200 m³/h; Debit_mini: 200 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL Tri; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 30 VL Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 2.77245 m2; Volume: 0.355489 m3
Données d'identification - Identifiant: 57
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VL, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 38 VL:293776
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; C: 0.639 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410074; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VL Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VL; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 78 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.50279 m2; Volume: 0.519948 m3
Données d'identification - Identifiant: 58
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VL ISOLE, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 38 VL ISOLE:293788
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; C: 0.666 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410072; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VL IS Mono RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VL ISOLE; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 88 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 3.1 A; Nombre_de_phases: 1; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 21.3677 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL ISOLE; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL ISOLE; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL ISOLE; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL ISOLE
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.55384 m2; Volume: 0.543951 m3
Données d'identification - Identifiant: 59
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VL ISOLE Tri, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 38 VL ISOLE Tri:293800
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; C: 0.666 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410073; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VL IS Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VL ISOLE Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 88 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL ISOLE Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL ISOLE Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL ISOLE Tri; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL ISOLE Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.55384 m2; Volume: 0.543951 m3
Données d'identification - Identifiant: 60
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction

# IfcFlowMovingDevice: EXTH ECOWATT PR 38 VL Tri, BIM_EXTH_ECOWATT_04à38_PR_VL:EXTH ECOWATT PR 38 VL Tri:293812
In: Niveau 0
Type - Material: Acier, galvanisé, Bleu, Vert, Noir, Jaune, Rouge
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Visibilité_marque: yes; Grille_extraction: 0.44 m; Nom de la famille: BIM_EXTH_ECOWATT_04à38_PR_VL
Type - Cotes(Type) - A: 1.106 m; B: 0.923 m; C: 0.639 m; E: 1.022 m; F: 0.894 m; G: 0.315 m; H: 0.323 m; Hauteur_porte: 0.562 m; I: 0.27 m; J: 0.345 m; Largeur_porte: 0.648 m; ØD1: 0.5 m; ØD1_Int: 0.496 m; Pos_H_inter: 0.159 m; Pos_V_inter: 0.136 m
Type - Données d'identification(Type) - Code_article: 5410075; Commentaires du type: Caisson d’extraction destiné à la ventilation mécanique basse pression; Fabricant: MVN; Lien_page_produit: https://www.mvnfrance.com/sites/default/files/type_contenu_telechargement/19_exth-ecowatt-pr_012020.pdf; Modèle: EXTH ECOWATT PR 38 VL Tri RMEC Caisson C4 VAV CAV COP; Nom du type: EXTH ECOWATT PR 38 VL Tri; Numéro OmniClass: 23.75.00.00; Titre OmniClass: Climate Control (HVAC)
Type - Données(Type) - Poids: 78 kg
Type - Electricité(Type) - Classe_de_protection_electrique: F; Courant_nominal: 1.3 A; Nombre_de_phases: 3; Protection_IP: IP54; Puissance_electrique: 700 W; Tension_nominale: 37.1612 V
Type - Génie climatique(Type) - Debit_maxi: 4200 m³/h; Debit_mini: 500 m³/h
Type - Matériaux et finitions(Type) - Materiau_caisson: Acier, galvanisé
Pset_ManufacturerTypeInformation - Manufacturer: MVN
Autre - Catégorie: Equipement de génie climatique; Famille: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL Tri; Famille et type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL Tri; ID du type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL Tri; Type: BIM_EXTH_ECOWATT_04à38_PR_VL: EXTH ECOWATT PR 38 VL Tri
Contraintes - Décalage: 0 m; Niveau: Niveau: Niveau 0; Hôte: Niveau : Niveau 0
Cotes - Surface: 3.50279 m2; Volume: 0.519948 m3
Données d'identification - Identifiant: 61
Génie climatique - Classification du système: Reprise,Puissance,Extraction d'air; Debit: 0 m3/s
Phase de construction - Phase de création: Nouvelle construction
